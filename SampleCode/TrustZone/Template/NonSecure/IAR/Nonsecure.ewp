# IAR project Nonsecure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART1_NS
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Nonsecure.bin
  ILINK.IlinkOutputFile: Nonsecure.out
  ILINK.IlinkIcfFile: M2354_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c
    ../../Secure/lib/: nsclib_Secure_IAR.o
  group User
    ../: main_ns.c
