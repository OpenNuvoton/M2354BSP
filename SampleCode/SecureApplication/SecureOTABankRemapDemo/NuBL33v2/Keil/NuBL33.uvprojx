# Keil uVision project NuBL33.uvprojx, settings and files
target NuBL33 (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL33_FW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: FwSign.bat .\NuBL33_FW.bin\EXE_ROM .\NuBL33_FW.bin\FWINFO 0x5D800
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0_NS NUMAKER_BOARD
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\NuBL2\ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL33.sct
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../: NuBL33_startup_M2354.s
  group User
    ../: NuBL33_main.c NuBL33_FwInfo.c
    ../../NuBL32v2/lib/: NuBL32_nsclib.o
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c
