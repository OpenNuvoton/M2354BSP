# Keil uVision project NuBL2.uvprojx, settings and files
target NuBL2_OTA_Client (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL2_FW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: FwSign.bat .\NuBL2_FW.bin\FLASH .\NuBL2_FW.bin\FWINFO 0x5E800
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0_NS NUMAKER_BOARD
  c include: ..\..\common\inc;..\..\NuBL2;..\..\Esp8266Lib;..\..\..\..\..\ThirdParty\FatFs\src;..\ota;..\esp;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL2.sct
  link misc: --import-cmse-lib-out ..\lib\NuBL2_nsclib.o --keep=NuBL2_lib0.o(*) --keep=NuBL_crypto.o(*)
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../: NuBL2_startup_M2354.s
  group User
    ../: NuBL2_main.c NuBL2_lib0.c partition_M2354.h NuBL2_FWinfo.c
    ../keyInfo/: LoadKeyStorage.s
  group Common
    ../../common/src/: NuBL_crypto.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c uart.c fmc.c sdh.c rng.c crypto.c
    ../: my_clk.c
  group ESP
    ../../Esp8266Lib/: buffer.c esp8266.c
    ../esp/: esp8266_ll.c
  group OTA
    ../ota/: ota.c ota_api.c ota_transfer.c commandhandler.o
  group FATFS
    ../../../../../ThirdParty/FatFs/src/: ff.c
    ../Fs/: diskio.c SDGlue.c
