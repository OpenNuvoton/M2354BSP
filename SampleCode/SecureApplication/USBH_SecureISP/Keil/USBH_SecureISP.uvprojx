# Keil uVision project USBH_SecureISP.uvprojx, settings and files
target USBH_SecureISP (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: USBH_SecureISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: ENABLE_ERROR_MSG,ENABLE_DEBUG_MSG
  c include: ..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\Library\UsbHostLib\src_hid;..\..\..\..\ThirdParty\FATFS\src
  asm define: Stack_Size = 0x4000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group User
    ../: main.c ProcessCommand.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c crc.c fmc.c rng.c crypto.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c usb_core.c
    ../: My_ohci.c
  group USBH_HID_Lib
    ../: My_hid_core.c
    ../../../../Library/UsbHostLib/src_hid/: hid_driver.c hid_parser.c
