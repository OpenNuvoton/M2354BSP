# IAR project Nonsecure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\..\Library\StdDriver\inc; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: Nonsecure.bin
  ILINK.IlinkOutputFile: Nonsecure.out
  ILINK.IlinkIcfFile: m2354_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Common Demo Tasks
    ../../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: blocktim.c countsem.c dynamic.c QueueOverwrite.c QueueSet.c recmutex.c
  group Demo App Source
    ../: FreeRTOSConfig.h main-blinky.c main.c ParTest_M2354.c
  group FreeRTOS source
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group NSC
    ../../Secure/: nsclib_Secure_IAR.o
  group System
    ../../: partition_M2354.h
    ../../../../../Library/StdDriver/src/: retarget.c
    ../../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
