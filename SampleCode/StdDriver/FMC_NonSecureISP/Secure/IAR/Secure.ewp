# IAR project Secure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: Secure.bin
  postbuild: cmd.exe /c copy "Release\Exe\nsclib_Secure_IAR.o" "..\lib"
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: M2354_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c
  group User
    ../: main.c
