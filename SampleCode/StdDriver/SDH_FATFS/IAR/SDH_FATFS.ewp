# IAR project SDH_FATFS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDH_FATFS.bin
  ILINK.IlinkOutputFile: SDH_FATFS.out
  ILINK.IlinkIcfFile: M2354.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group FATFS
    ../../../../ThirdParty/FatFs/src/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sdh.c sys.c timer.c uart.c
  group User
    ../: diskio.c main.c SDGlue.c
