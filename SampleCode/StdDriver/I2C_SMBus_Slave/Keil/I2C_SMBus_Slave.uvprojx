# Keil uVision project I2C_SMBus_Slave.uvprojx, settings and files
target I2C_SMBus_Slave (6220000::V6.22::ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: I2C_SMBus_Slave
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\StdDriver\inc;..\..\SDH_FATFS;..\..\..\..\ThirdParty\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.S
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c i2c.c retarget.c sys.c gpio.c
