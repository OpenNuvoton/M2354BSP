# IAR project USBH_MassStorage.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ENABLE_ERROR_MSG; ENABLE_DEBUG_MSG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\ThirdParty\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MassStorage.bin
  ILINK.IlinkOutputFile: USBH_MassStorage.out
  ILINK.IlinkIcfFile: M2354.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c
  group ThirdParty_FatFs
    ../../../../ThirdParty/FatFs/src/: ff.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group User
    ../: diskio.c main.c
