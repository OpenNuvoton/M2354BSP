# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_MultiBoot.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot.out
  ILINK.IlinkIcfFile: FMC_MultiBoot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_Boot0 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_Boot0.bin
  ILINK.IlinkIcfFile: FMC_Boot0.icf
configuration FMC_Boot1 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_Boot1.bin
  ILINK.IlinkIcfFile: FMC_Boot1.icf
configuration FMC_Boot2 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_Boot2.bin
  ILINK.IlinkIcfFile: FMC_Boot2.icf
configuration FMC_Boot3 (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: FMC_Boot3.bin
  ILINK.IlinkIcfFile: FMC_Boot3.icf
configuration FMC_BootLD (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: FMC_BootLD.icf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
