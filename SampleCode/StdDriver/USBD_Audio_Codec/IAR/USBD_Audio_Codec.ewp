# IAR project USBD_Audio_Codec.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio_Codec.bin
  ILINK.IlinkOutputFile: USBD_Audio_Codec.out
  ILINK.IlinkIcfFile: M2354.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c i2s.c pdma.c retarget.c sys.c timer.c uart.c usbd.c
  group User
    ../: audio_codec.c config_pdma.c descriptors.c main.c usbd_audio.c
