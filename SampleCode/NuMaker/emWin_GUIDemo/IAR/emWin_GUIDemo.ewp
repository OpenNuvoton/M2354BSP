# IAR project emWin_GUIDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __DEMO_320x240__
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2354\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\emWin\Config; ..\..\..\..\ThirdParty\emWin\Include; ..\..\..\..\Library\NuMaker\emWin\lcm; ..\..\..\..\Library\NuMaker\emWin\tslib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emWin_GUIDemo.bin
  ILINK.IlinkOutputFile: emWin_GUIDemo.out
  ILINK.IlinkIcfFile: M2354.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\ThirdParty\emWin\Lib\NUemWin_CM23_IAR.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../Application/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group lcm
    ../../../../Library/NuMaker/emWin/lcm/: ILI9341.c lcm.h ST7735.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c eadc.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c
  group tslib
    ../../../../Library/NuMaker/emWin/tslib/: fbutils.c M2354_320x240.c M2354TouchPanel.c M2354TouchPanel.h testutils.c ts_calibrate.c
  group User
    ../: main.c
