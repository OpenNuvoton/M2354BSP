# Keil uVision project Audio.uvprojx, settings and files
target PlaySin (6070000::V6.7::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NVSP0015_Type_C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: OPTION = 0
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2351.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c fmc.c i2s.c i2c.c timer.c gpio.c
target Loopback (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: as above
  output: NVSP0015_Type_C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: OPTION = 1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
