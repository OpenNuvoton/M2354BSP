# Keil uVision project BME680_and_LCD.uvprojx, settings and files
target BME680_and_LCD (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: BME680_and_LCD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\LCDLib\Include;..\..\..\..\ThirdParty\BME680;..\..\LCD_BME680
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group User
    ../: main.c m2354_bme680.c
  group BME680
    ../../../../ThirdParty/BME680/: bme680.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c i2c.c rtc.c lcd.c
    ../../../../Library/LCDLib/Source/: lcdlib.c
